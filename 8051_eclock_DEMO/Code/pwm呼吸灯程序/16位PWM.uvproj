# Keil uVision project 16位PWM.uvproj, settings and files
target 呼吸灯 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 16位PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group 16位PWM
    ./: main.c

# Keil uVision project DS3231.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: DS3231 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 3231.c 3231.h TM1637.c TM1637.h delay.c delay.h
